# Autodesk Inventor assembly: Spacer Wedge
## iProperties
Created: 2007-04
Part Number: Spacer Wedge
Document SubType Name: Assembly
Designer: Admin
Author: Admin
